Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-09-27T15:13:05
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Sep 27 15:13:05 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{5FE01BB9-5B87-4509-8DFC-EA7C9A652E03}\ifc * Database version: 5507 * Database creation date: Wed Sep 27 15:13:04 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Sep 27 15:13:05 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Sep 27 15:13:05 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-234032 BIMCAD EU_Batch 2_1253 models\Working\3D Content\Part 1 - 150 Models\Normal Holes\IFC\GLE600_170_25.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Identity Data - Building Story: yes; Structural: no; Name: Level 1
Dimensions - Computation Height: 0 mm
Graphics - Line Pattern: -3000010; Color: 0; Symbol at End 1 Default: no; Symbol at End 2 Default: yes; Line Weight: 1

# IfcBuildingElementProxy: GLE600_170_25, GLE600_170_25:GLE600_170_25:140211
In: Level 1
Material: Galvanised
Phasing - Phase Created: New Construction
Other - Schedule Level: Level: Level 1
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Dimensions - Volume: 0.00472941 ft3
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GLE600/170/2.5
Identity Data - Model ID: 0170241818178322869022063790387304868051; Copyright: ©Simpson Strong-Tie; UniClass Title: Joist hangers; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; Provide Feedback: mailto:EUdrawings@strongtie.com; Description: Joist hanger; OmniClass Number: 23.20.40.11.24.14; UniClass Number: Pr_20_29_31_44; ObjectType: GLE600/170/2.5; Name: GLE600/170/2.5; Manufacturer: Simpson Strong-Tie; OmniClass Title: Wood Connectors; Model: GLE600/170/2.5; Product Type: Joist hanger; URL: www.strongtie.eu
General - ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; Reference: GLE600/170/2.5; Density: 1.06; EPD: https://www.strongtie.eu/eu-EU/EPD; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets
Materials and Finishes - Product Material: Galvanised
