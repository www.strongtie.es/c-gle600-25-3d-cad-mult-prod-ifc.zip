Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-09-27T15:13:04
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Sep 27 15:13:04 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{B4EE9CBE-836D-44C8-A0F5-36C8A5929254}\ifc * Database version: 5507 * Database creation date: Wed Sep 27 15:13:04 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Sep 27 15:13:04 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Sep 27 15:13:04 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-234032 BIMCAD EU_Batch 2_1253 models\Working\3D Content\Part 1 - 150 Models\Normal Holes\IFC\GLE600_168_25.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Graphics - Symbol at End 1 Default: no; Line Weight: 1; Color: 0; Symbol at End 2 Default: yes; Line Pattern: -3000010
Dimensions - Computation Height: 0 mm
Identity Data - Name: Level 1; Structural: no; Building Story: yes
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point

# IfcBuildingElementProxy: GLE600_168_25, GLE600_168_25:GLE600_168_25:139583
In: Level 1
Material: Galvanised
Phasing - Phase Created: New Construction
Dimensions - Volume: 0.00472941 ft3
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Other - Schedule Level: Level: Level 1
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GLE600/168/2.5
Identity Data - OmniClass Number: 23.20.40.11.24.14; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; ObjectType: GLE600/168/2.5; UniClass Number: Pr_20_29_31_44; Model: GLE600/168/2.5; Name: GLE600/168/2.5; Description: Joist hanger; Copyright: ©Simpson Strong-Tie; UniClass Title: Joist hangers; Provide Feedback: mailto:EUdrawings@strongtie.com; URL: www.strongtie.eu; Model ID: 0170241818178322869022063790387304868051; Manufacturer: Simpson Strong-Tie; Product Type: Joist hanger; OmniClass Title: Wood Connectors
General - ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; Density: 1.06; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets; Reference: GLE600/168/2.5; EPD: https://www.strongtie.eu/eu-EU/EPD
Materials and Finishes - Product Material: Galvanised
