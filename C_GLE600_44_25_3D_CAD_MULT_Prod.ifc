Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-11-09T15:23:30
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Nov 09 15:23:30 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{4A44DFD9-7DBA-4673-94A3-6153C4E37AA2}\ifc * Database version: 5507 * Database creation date: Thu Nov 09 15:23:30 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Nov 09 15:23:30 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Nov 09 15:23:30 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-234032 BIMCAD EU_Batch 2_1253 models\Working\3D Content\Part 4 - 235 Models\Normal Holes\RFA 3D\GLE600_44_25.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Dimensions - Computation Height: 0 mm
Graphics - Symbol at End 1 Default: no; Symbol at End 2 Default: yes; Line Weight: 1; Color: 0; Line Pattern: -3000010

# IfcBuildingElementProxy: GLE600_44_25, GLE600_44_25:GLE600_44_25:138955
In: Level 1
Material: Galvanised
Dimensions - Volume: 0.00471616 ft3
Phasing - Phase Created: New Construction
Other - Schedule Level: Level: Level 1
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GLE600/44/2.5
Identity Data - UniClass Title: Joist hangers; Provide Feedback: mailto:EUdrawings@strongtie.com; Name: GLE600/44/2.5; OmniClass Title: Wood Connectors; Model: GLE600/44/2.5; UniClass Number: Pr_20_29_31_44; ObjectType: GLE600/44/2.5; URL: www.strongtie.eu; Product Type: Joist hanger; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; Model ID: 0200181214085717154208661832541747226109; OmniClass Number: 23.20.40.11.24.14; Description: Joist hanger; Manufacturer: Simpson Strong-Tie; Copyright: ©Simpson Strong-Tie
General - EPD: https://www.strongtie.eu/eu-EU/EPD; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets; Density: 0.983; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; Reference: GLE600/44/2.5
Materials and Finishes - Product Material: Galvanised
