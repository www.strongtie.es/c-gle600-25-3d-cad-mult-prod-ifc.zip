Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-09-27T15:13:18
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Sep 27 15:13:18 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{2322507B-B9C2-4542-A444-B366C9C6DD11}\ifc * Database version: 5507 * Database creation date: Wed Sep 27 15:13:18 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Sep 27 15:13:18 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Sep 27 15:13:18 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-234032 BIMCAD EU_Batch 2_1253 models\Working\3D Content\Part 1 - 150 Models\Normal Holes\IFC\GLE600_206_25.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Identity Data - Name: Level 1; Building Story: yes; Structural: no
Dimensions - Computation Height: 0 mm
Graphics - Symbol at End 2 Default: yes; Line Weight: 1; Symbol at End 1 Default: no; Color: 0; Line Pattern: -3000010

# IfcBuildingElementProxy: GLE600_206_25, GLE600_206_25:GLE600_206_25:151515
In: Level 1
Material: Galvanised
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Phasing - Phase Created: New Construction
Other - Schedule Level: Level: Level 1
Dimensions - Volume: 0.00472941 ft3
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GLE600/206/2.5
Identity Data - ObjectType: GLE600/206/2.5; UniClass Title: Joist hangers; Copyright: ©Simpson Strong-Tie; Provide Feedback: mailto:EUdrawings@strongtie.com; Model: GLE600/206/2.5; Name: GLE600/206/2.5; Product Type: Joist hanger; OmniClass Title: Wood Connectors; URL: www.strongtie.eu; Manufacturer: Simpson Strong-Tie; Description: Joist hanger; OmniClass Number: 23.20.40.11.24.14; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; UniClass Number: Pr_20_29_31_44; Model ID: 0170241818178322869022063790387304868051
General - EPD: https://www.strongtie.eu/eu-EU/EPD; Density: 1.06; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets; Reference: GLE600/206/2.5; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking
Materials and Finishes - Product Material: Galvanised
